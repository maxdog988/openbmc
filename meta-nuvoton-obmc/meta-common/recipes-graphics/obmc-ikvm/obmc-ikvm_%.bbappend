#LIC_FILES_CHKSUM = "file://LICENSE;md5=d32239bcb673463ab874e80d47fae504"
#SRC_URI:nuvoton := "git://github.com/Nuvoton-Israel/obmc-ikvm.git;branch=master;protocol=https"
#SRCREV:nuvoton := "6437f2e7311ceb91e2505cef277fb451c03de3f2"

LIC_FILES_CHKSUM = "file://LICENSE;md5=75859989545e37968a99b631ef42722e"
SRC_URI:nuvoton := "git://github.com/Nuvoton-Israel/obmc-ikvm.git;branch=upstream-v4l2;protocol=https"
SRCREV:nuvoton := "b4ae317e8b441354c6c4dbe61e359b2ce56326bf"
