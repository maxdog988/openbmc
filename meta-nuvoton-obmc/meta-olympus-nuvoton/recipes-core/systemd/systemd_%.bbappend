FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

#SRC_URI:append = " \
#    file://0001-networkd-create-new-socket.patch \
#"
