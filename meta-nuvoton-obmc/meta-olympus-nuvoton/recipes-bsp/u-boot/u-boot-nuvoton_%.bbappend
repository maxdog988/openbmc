UBOOT_MAKE_TARGET:append = " DEVICE_TREE=${UBOOT_DEVICETREE}"

