FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

#SRC_URI:append = " file://0001-build-meson-fix-python-command-parameter.patch"
SRC_URI:append = " file://0001-logging-test-report-a-redfish-event-success-when-add.patch"

