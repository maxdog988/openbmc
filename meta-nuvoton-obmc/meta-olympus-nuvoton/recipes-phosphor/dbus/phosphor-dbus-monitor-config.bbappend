PHOSPHOR_DBUS_MONITOR_CONFIGS:append = " olympus-nuvoton-yaml-config"
