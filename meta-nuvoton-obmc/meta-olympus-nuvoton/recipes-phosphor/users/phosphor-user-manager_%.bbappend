
FILESEXTRAPATHS:append := "${THISDIR}/${PN}:"

SRC_URI:append = " file://0001-Throw-NotAllowed-when-delete-or-disable-root.patch"