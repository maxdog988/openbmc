# enable debug log
# EXTRA_OEMAKE:append = " CFG_TEE_CORE_DEBUG=y CFG_TEE_CORE_LOG_LEVEL=3"
