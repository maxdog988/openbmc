FILESEXTRAPATHS:prepend := "${THISDIR}/u-boot-nuvoton:"
SRC_URI:append = " file://0002-Enable-openbmc-copy-base-file-to-ram-feature.patch"
