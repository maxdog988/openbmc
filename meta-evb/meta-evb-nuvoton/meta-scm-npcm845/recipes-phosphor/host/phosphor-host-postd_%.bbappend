SNOOP_DEVICE = "npcm7xx-lpc-bpc0"
POST_CODE_BYTES = "4"
