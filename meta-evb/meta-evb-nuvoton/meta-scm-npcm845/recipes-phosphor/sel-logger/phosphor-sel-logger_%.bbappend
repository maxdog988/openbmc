PACKAGECONFIG:append:scm-npcm845 = " log-watchdog log-threshold"
