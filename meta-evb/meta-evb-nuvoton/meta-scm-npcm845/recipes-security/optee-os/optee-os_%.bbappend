# enable debug log
# EXTRA_OEMAKE:append:evb-npcm845 = " CFG_TEE_CORE_DEBUG=y CFG_TEE_CORE_LOG_LEVEL=3"
