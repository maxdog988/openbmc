SRCREV = "4a0758cf7c2ea1505e648346a7a407c3974467a7"

OUTPUT_BB_TIP_BIN    = "Images/tip"
OUTPUT_BB_NO_TIP_BIN = "Images/no_tip"

require npcm8xx-bootblock.inc
