<<<<<<<< HEAD:meta-nuvoton/recipes-bsp/images/npcm8xx-tip-fw_0.7.5.0.6.4.bb
SRCREV = "6a4c6119a60bd7af259a32c36196e70a7ee61661"
========
SRCREV = "c0418a3e5df233bb9c69b805c60d606fa3066654"
>>>>>>>> 5ae2f38601:meta-nuvoton/recipes-bsp/images/npcm8xx-tip-fw_0.7.4.0.6.3.bb

OUTPUT_BIN = "output_binaries_${DEVICE_GEN}_${IGPS_MACHINE}"

require npcm8xx-tip-fw.inc
