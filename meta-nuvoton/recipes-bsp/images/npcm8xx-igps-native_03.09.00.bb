# tag IGPS_03.09.00
SRCREV = "832901104385f0b56014c0f6b59f69a9dbb74fd6"

require npcm8xx-igps.inc
